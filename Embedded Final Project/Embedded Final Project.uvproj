# Keil uVision project Embedded Final Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Embedded Final Project
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./HAL/headers/: Buzzer.h GPS.h LCD.h
    ./HAL/src/: Buzzer.c GPS.c LCD.c
    ./MCAL/headers/: Delay.h GPIO.h tm4c123gh6pm.h UART.h
    ./MCAL/src/: Delay.c UART.c
    ./: startup_TM4C123.s main.c
    ./services/src/: Functions.c
    ./services/headers/: Functions.h
